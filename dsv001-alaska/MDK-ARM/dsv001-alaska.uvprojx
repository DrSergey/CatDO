# Keil uVision project dsv001-alaska.uvprojx, settings and files
target dsv001-alaska (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: dsv001-alaska
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/BSP/STM32F429I-Discovery;../MDK-ARM;../MDK-ARM/Hardware/MLX90614XXX;../MDK-ARM/Hardware;../MDK-ARM/Events;../MDK-ARM/Digital_Filter
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
    ./: Forms_01.c Forms_01.h
    ../Inc/: stm32f4xx_it.h
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_gpio.c stm32f4xx_ll_fmc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal.c stm32f4xx_hal_dma.c stm32f4xx_hal_dsi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_sdram.c
  group BSP/STM32F429I-Discovery
    ../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c stm32f429i_discovery_lcd.h
  group BSP/Components
    ../Drivers/BSP/Components/ili9341/: ili9341.c
  group Hardware
    ./Hardware/MLX90614XXX/: mlx90614BCC.h
    ./: mlx90614BCC.c
    ./Hardware/: HW_Robo1.c HW_Robo1.h HW_Internal_STM32F429.h HW_Internal_STM32F429.c
  group Events
    ./Events/: EventHandler_s_Robo1.h
    ./: EventHandler_s_Robo1.c
  group Digital_Filter
    ./Digital_Filter/: D_Filter.c D_Filter.h
software components: CMSIS:CORE 4.1.0
